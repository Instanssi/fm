<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>deviation_monitor</value></param>
<param><key>author</key><value>Zouppen</value></param>
<param><key>description</key><value>Demodulates FM signal and outputs: left channel Q, right channel A</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Analog QAM decoder (for FM monitoring)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>decimate</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>decimate</value></param>
<param><key>section</key><value>tuning</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>deviation</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>90e3</value></param>
<param><key>option</key><value>deviation</value></param>
<param><key>section</key><value>tuning</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>frequency</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>100000000</value></param>
<param><key>option</key><value>frequency</value></param>
<param><key>section</key><value>tuning</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>offtune</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>200000</value></param>
<param><key>option</key><value>offtune</value></param>
<param><key>section</key><value>tuning</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>960000</value></param>
<param><key>option</key><value>samp_rate</value></param>
<param><key>section</key><value>tuning</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>squelch</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>option</key><value>squelch</value></param>
<param><key>section</key><value>tuning</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>transition</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>1e4</value></param>
<param><key>option</key><value>transition</value></param>
<param><key>section</key><value>tuning</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>0.5</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_descriptor_sink</key>
<param><key>id</key><value>blocks_file_descriptor_sink_0</value></param>
<param><key>fd</key><value>1</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>2**15</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>2**15</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>squelch</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>squelch*0.95</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>conf</value></param>
<param><key>label</key><value>Radio configuration file</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>offtuner</key>
<param><key>id</key><value>offtuner_0</value></param>
<param><key>deviation</key><value>deviation</value></param>
<param><key>decimate</key><value>decimate</value></param>
<param><key>frequency</key><value>frequency</value></param>
<param><key>conf</key><value>conf</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>transition</key><value>transition</value></param>
<param><key>offtune</key><value>offtune</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>xmin</key><value>-1</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_file_descriptor_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>offtuner_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>offtuner_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
