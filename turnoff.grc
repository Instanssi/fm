<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>turnoff</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Center frequency (MHz)</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>145</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>5e6</value></param>
<param><key>freq0</key><value>1e6*frequency</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>radio</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>5e6</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio</value></param>
<param><key>label</key><value>Radio device (osmocom)</value></param>
<param><key>short_id</key><value>R</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>driver=lime,soapy=0</value></param>
</block>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
