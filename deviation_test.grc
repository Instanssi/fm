<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>deviation_test</value></param>
<param><key>author</key><value>Joel Lehtonen</value></param>
<param><key>description</key><value>Tests deviation using slow sawtooth wawe</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Deviation tester</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>label</key><value>Audio amplitude 0...1</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>2*amplitude</value></param>
<param><key>freq</key><value>0.1</value></param>
<param><key>offset</key><value>-amplitude</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_dev</value></param>
<param><key>label</key><value>Audio device</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>plughw:0,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>label</key><value>Audio input rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>audio_dev</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
