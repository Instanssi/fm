<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>offtuner</value></param>
<param><key>author</key><value>Zouppen</value></param>
<param><key>description</key><value>Receives using Osmocom API with offset and band-passes the signal</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Offset tuner and bandpass</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>antenna</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value></value></param>
<param><key>option</key><value>antenna</value></param>
<param><key>section</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>device</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value></value></param>
<param><key>option</key><value>device</value></param>
<param><key>section</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>gain_bb</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>bb</value></param>
<param><key>section</key><value>gain</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>gain_if</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>if</value></param>
<param><key>section</key><value>gain</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>gain_rf</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>rf</value></param>
<param><key>section</key><value>gain</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ppm</value></param>
<param><key>config_file</key><value>conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>ppm</value></param>
<param><key>section</key><value>radio</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>conf</value></param>
<param><key>label</key><value>Radio configuration file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimate</value></param>
<param><key>label</key><value>Decimate after demodulating</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deviation</value></param>
<param><key>label</key><value>Channel width (deviation) in Hz</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>90000</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>offtune</value></param>
<param><key>decim</key><value>decimate</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.complex_band_pass(1,samp_rate,-deviation,deviation, transition)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Payload center requency (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100.2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offtune</value></param>
<param><key>label</key><value>Tuner offset to avoid LO peak (Hz)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>960000</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>sdr</value></param>
<param><key>ant0</key><value>antenna</value></param>
<param><key>bb_gain0</key><value>gain_bb</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>frequency-offtune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>gain_if</value></param>
<param><key>gain0</key><value>gain_rf</value></param>
<param><key>args</key><value>device</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>transition</value></param>
<param><key>label</key><value>Transition width in FIR filter (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e4</value></param>
</block>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdr</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
